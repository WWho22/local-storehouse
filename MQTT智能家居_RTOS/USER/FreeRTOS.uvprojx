# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\USART2;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\SYSTEM\includes;..\MQTTClient\common;..\MQTTClient\mqtt;..\MQTTClient\mqttclient;..\MQTTClient\network;..\MQTTClient\platform\FreeRTOS;..\MQTTClient\network\mbedtls\include\mbedtls;..\MQTTClient\common\log;..\MQTTClient\common\PLOOC;..\HARDWARE\OLED;..\HARDWARE\GPIO;..\HARDWARE\DHT11;..\HARDWARE\ESP8266;..\HARDWARE\RingBuffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ./: main.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/OLED/: oled.h oled.c
    ../HARDWARE/GPIO/: gpio.c gpio.h
    ../HARDWARE/DHT11/: dht11.c dht11.h
    ../HARDWARE/ESP8266/: esp8266.c esp8266.h
    ../HARDWARE/RingBuffer/: ringbuffer.c ringbuffer.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_can.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_flash.c stm32f4xx_sdio.c
  group README
    ../: readme.txt
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group TASK
    ../TASK/: queue_send.c queue_receive.c test_task.c data_handle.c
  group Common
    ../MQTTClient/common/: mqtt_list.c random.c
  group MQTT
    ../MQTTClient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MQTTClient
    ../MQTTClient/mqttclient/: mqttclient.c
  group Network
    ../MQTTClient/network/: nettype_tcp.c network.c
  group Platform
    ../MQTTClient/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
